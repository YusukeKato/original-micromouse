# Repository YusukeKato/original-micromouse

File README.md:

# original-micromouse
自作マウス研修のタスク管理など

## KiCad design circuit_diagram/original-mouse.kicad_pcb

Parts:
BT1: Lipo 2cell 7.4V; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
C1, C3, C7, C12, C13, C14, C15, C16, C19, C20, C21, C22, C23, C27, C29: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C4, C28: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5, C24, C25: 2.2u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6: 33u; CP_Elec_6.3x7.7
C8, C9, C10, C11, C26: 0.01u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C17: 10u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C18: 4.7u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: KM-23ESGC; SOT-23
D2, D3, D4, D5: OSHR1608C1A; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D6, D7, D8, D9: OS5RKA5111A; LED_D5.0mm_Horizontal_O3.81mm_Z3.0mm
D10: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
FB1: MZ1608-102Y; IND_BOURNS_1608
J1, J2: Conn_02x03_Odd_Even; IDC-Header_2x03_P2.54mm_Vertical
J3: Conn_01x08; PinSocket_1x08_P2.54mm_Vertical
Q1: TJ8S06M3L; TO-252-2
Q2, Q3, Q4, Q5, Q6: BSS138; SOT-23
Q7, Q8, Q9, Q10: ST-1KL3A; TR-F
R1: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R15, R18, R20, R23, R26: 47k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R10, R11, R12, R29, R31, R33, R35, R36, R37, R38: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R5, R6, R7, R8, R9, R13, R28, R30, R32, R34, R39: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14, R17, R19, R22, R25: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16, R21, R24, R27: 10 1/8W; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV1: 10k; BOURNS-3362P_pot
SW1: SW_SPDT; SSSS213202
SW2, SW3, SW4, SW5, SW6: SW_Push; TVAF06-A020B-R
U1: NJM7805SDL1; TO-252-2
U2: NJM2845DL1-33; TO-252-2
U3: PKMCS0909E4000-R1; Buzzer_Murata_PKMCS0909E
U4: ICM-20649; InvenSense_QFN-24_3x3mm_P0.4mm
U5: DRV8835
U6: STM32F405RGTx; LQFP-64_10x10mm_P0.5mm

Connections:
+3.3V: C5.1, C6.1, C7.1, C12.1, C14.1, C15.1, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, FB1.1, J3.1, R10.1, R11.1, R12.1, R13.1, R16.1, R21.1, R24.1, R27.1, R36.1, R39.1, SW6.1, U2.3 (Vout), U3.1, U4.8 (VDDIO), U4.13 (VDD), U5.11 (MODE), U5.12 (VCC), U6.1 (VBAT), U6.19 (VDD), U6.32 (VDD), U6.48 (VDD), U6.64 (VDD)
+3.3VA: C26.1, C27.1, C28.1, FB1.2, Q7.1 (C), Q8.1 (C), Q9.1 (C), Q10.1 (C), U6.13 (VDDA)
+5V: C3.1, C4.1, J1.4, J2.4, U1.3 (Vout), U2.1 (Vin)
+BATT: C2.1, C16.1, C17.1, Q1.2 (D), R2.1, U1.1 (Vin), U5.1 (VM)
BLED0: R5.1, U6.40 (PC9)
BLED1: R4.1, U6.39 (PC8)
BOOT0: R38.1, SW6.2, U6.60 (BOOT0)
BUZZER: RV1.1, U6.57 (PB5)
DIR_L: U5.10 (AIN1/APHASE), U6.43 (PA10)
DIR_R: U5.8 (BIN1/BPHASE), U6.44 (PA11)
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, D1.3 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D10.1 (K), J1.3, J2.3, J3.3, Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), Q6.2 (S), R3.2, R15.2, R18.2, R20.2, R23.2, R26.2, R28.2, R29.2, R30.2, R31.2, R32.2, R33.2, R34.2, R35.2, R37.2, R38.2, RV1.3, SW1.1 (A), SW2.2, SW3.2, SW4.2, SW5.2, U1.2 (GND), U2.2 (GND), U4.11 (FSYNC), U4.18 (GND), U4.20 (RESV), U5.6 (GND), U6.12 (VSSA), U6.18 (VSS), U6.63 (VSS)
LED0: R9.1, U6.53 (PC12)
LED1: R8.1, U6.52 (PC11)
LED2: R7.1, U6.51 (PC10)
LED3: R6.1, U6.50 (PA15)
LEFT_ENCODER_A: J2.6, U6.37 (PC6)
LEFT_ENCODER_B: J2.5, U6.38 (PC7)
LEFT_FRONT: R25.1, U6.30 (PB11)
LEFT_FRONT_AD: C10.2, R33.1, U6.26 (PB0)
LEFT_MOTOR+: J2.2, U5.2 (AOUT1)
LEFT_MOTOR-: J2.1, U5.3 (AOUT2)
LEFT_SIDE: R19.1, U6.33 (PB12)
LEFT_SIDE_AD: C11.2, R35.1, U6.27 (PB1)
NRST: C29.1, J3.5, SW5.1, U6.7 (NRST)
unnamed: BT1.1 (+), Q1.3 (S), R1.1
unnamed: D1.1 (A1), R4.2
unnamed: D1.2 (A2), R5.2
unnamed: D2.2 (A), R6.2
unnamed: D3.2 (A), R7.2
unnamed: D4.2 (A), R8.2
unnamed: D5.2 (A), R9.2
unnamed: D6.2 (A), R16.2
unnamed: D6.1 (K), Q3.3 (D)
unnamed: D7.2 (A), R21.2
unnamed: D7.1 (K), Q4.3 (D)
unnamed: D8.2 (A), R24.2
unnamed: D8.1 (K), Q5.3 (D)
unnamed: D9.2 (A), R27.2
unnamed: D9.1 (K), Q6.3 (D)
unnamed: D10.2 (A), R39.2
unnamed: Q1.1 (G), R1.2, SW1.2 (B)
unnamed: Q2.3 (D), R13.2, U3.2
unnamed: Q2.1 (G), R14.2, R15.1
unnamed: Q3.1 (G), R17.2, R18.1
unnamed: Q4.1 (G), R19.2, R20.1
unnamed: Q5.1 (G), R22.2, R23.1
unnamed: Q6.1 (G), R25.2, R26.1
unnamed: C8.1, Q7.2 (E), R28.1
unnamed: C9.1, Q8.2 (E), R30.1
unnamed: C10.1, Q9.2 (E), R32.1
unnamed: C11.1, Q10.2 (E), R34.1
unnamed: R14.1, RV1.2
unnamed: C13.1, U4.10 (REGOUT)
unnamed: R37.1, U6.28 (PB2)
unnamed: C25.1, U6.31 (VCAP_1)
unnamed: C24.1, U6.47 (VCAP_2)
PWM_L: U5.9 (AIN2/AENBL), U6.41 (PA8)
PWM_R: U5.7 (BIN2/BENBL), U6.42 (PA9)
RIGHT_ENCODER_A: J1.6, U6.58 (PB6)
RIGHT_ENCODER_B: J1.5, U6.59 (PB7)
RIGHT_FRONT: R22.1, U6.15 (PA1)
RIGHT_FRONT_AD: C9.2, R31.1, U6.25 (PC5)
RIGHT_MOTOR+: J1.2, U5.4 (BOUT1)
RIGHT_MOTOR-: J1.1, U5.5 (BOUT2)
RIGHT_SIDE: R17.1, U6.14 (PA0)
RIGHT_SIDE_AD: C8.2, R29.1, U6.24 (PC4)
SPI1_CS: R36.2, U4.22 (nCS), U6.20 (PA4)
SPI1_MISO: U4.9 (SDO/AD0), U6.22 (PA6)
SPI1_MOSI: U4.24 (SDA/SDI), U6.23 (PA7)
SPI1_SCLK: U4.23 (SCL/SCLK), U6.21 (PA5)
SW0: R10.2, SW2.1, U6.36 (PB15)
SW1: R11.2, SW3.1, U6.35 (PB14)
SW2: R12.2, SW4.1, U6.34 (PB13)
SWCLK: J3.2, U6.49 (PA14)
SWDIO: J3.4, U6.46 (PA13)
SWO: J3.6, U6.55 (PB3)
UART_RX: J3.7, U6.17 (PA3)
UART_TX: J3.8, U6.16 (PA2)
VBAT_AD: C1.1, R2.2, R3.1, U6.8 (PC0)

Notes on the sheet:
LED
Power
Buzzer
Motor Driver
Motor and Encoder
Sensor
表記のない抵抗の定格電力、許容誤差は、1/10W、±1% 表記のないコンデンサの耐圧、許容誤差は、10V、±10%
Micon
Switch
IMU

Board: 2 copper layers, 70.4 x 100.0 mm, 106 parts (0 on the bottom side), 79 nets.

## Commit log

2023-06-30 回路のブロック図を作成
2023-07-03 回路のブロック図を追加
2023-09-20 回路図を追加
2023-10-20 エラー解決
2023-10-25 ピン割り当て図を追加
2023-10-30 ブザー回路を修正
2023-12-06 フットプリントの割り当て
2024-01-30 配線だいたい完了
2024-01-30 回路図を更新
2024-01-31 配線完了
2024-01-31 回路にバージョンを記載
2024-02-02 レビューに対応して修正
